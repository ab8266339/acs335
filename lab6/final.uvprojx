# Keil uVision project final.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: final
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c my_headers.c Thread.c my_headers.h Thread.h
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.4.0, Device:STM32Cube HAL:Common 1.4.0, Device:STM32Cube HAL:Cortex 1.4.0, Device:STM32Cube HAL:DMA 1.4.0, Device:STM32Cube HAL:GPIO 1.4.0, Device:STM32Cube HAL:PWR 1.4.0, Device:STM32Cube HAL:RCC 1.4.0, Device:STM32Cube HAL:SPI 1.4.0, Device:STM32Cube HAL:TIM 1.4.0, Device:Startup 2.4.0
